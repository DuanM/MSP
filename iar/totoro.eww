<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\src\app\proj\app.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\platform\proj\platform.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\sensor\proj\sensor.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\src\stack\proj\stack.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>totoro_debug</name>
            <member>
                <project>app</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>platform</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>sensor</project>
                <configuration>Debug</configuration>
            </member>
            <member>
                <project>stack</project>
                <configuration>Debug</configuration>
            </member>
        </batchDefinition>
        <batchDefinition>
            <name>totoro_release</name>
            <member>
                <project>app</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>platform</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>sensor</project>
                <configuration>Release</configuration>
            </member>
            <member>
                <project>stack</project>
                <configuration>Release</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
