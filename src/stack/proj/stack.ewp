# IAR project stack.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\platform\hal; ..\..\platform\osel\; ..\..\platform\osel\uCOS-II\Config; ..\..\platform\osel\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\platform\osel\uCOS-II\Source; ..\..\stack\include\; ..\..\include\platform; ..\..\include\platform\hal; ..\..\include\platform\lib; ..\..\include\platform\osel; ..\..\include\sensor; ..\..\include\app; ..\..\include\stack; ..\..\app\include; ..\..\include\app\intelligence
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: stack.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: mac_handle.c mac_pib.c mac_slot.c mac_trans.c phy.c stack.c stack_analysis.c
  group include
    ../include/: mac.h stack_priv.h
    ../../include/stack/: stack.h
