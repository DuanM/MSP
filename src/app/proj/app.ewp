# IAR project app.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\platform\hal; ..\..\platform\osel\; ..\..\platform\osel\uCOS-II\Config; ..\..\platform\osel\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\platform\osel\uCOS-II\Source; ..\..\include\platform; ..\..\include\platform\hal; ..\..\include\platform\lib; ..\..\include\platform\osel; ..\..\include\sensor; ..\..\include\app; ..\..\include\stack; ..\..\include\sensor; ..\..\app\include; ..\intelligence; ..\..\include\app\intelligence; ..\..\stack\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MTCPV1002.bin
  ILINK.IlinkOutputFile: app.out
  ILINK.IlinkIcfFile: $WS_DIR$\linker\msp432p401r.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: app.c app_dbg.c app_gps.c app_handle.c app_uart_cfg.c control_io.c device.c
  group include/app
    ../../include/app/: app.h app_dbg.h device.h
    ../include/: control_io.h test.h
  group include/platform
    ../../include/platform/: nwk.h platform.h
  group include/platform/hal
    ../../include/platform/hal/: hal_misc.h hal_rf.h hal_timer.h hal_uart.h
  group include/platform/lib
    ../../include/platform/lib/: check.h crc.h debug.h kbuf.h list.h memory.h queue.h
  group include/platform/osel
    ../../include/platform/osel/: osel_event.h osel_kernel.h osel_task.h
  group include/sensor
    ../../include/sensor/: sensor.h
  group include/stack
    ../../include/stack/: stack.h
  group init
    ../init/: init.c
  group lib
    ../../platform/proj/Debug/Exe/: platform.a
    ../../sensor/proj/Debug/Exe/: sensor.a
    ../../stack/proj/Debug/Exe/: stack.a
  group test
    ../test/: test.c
