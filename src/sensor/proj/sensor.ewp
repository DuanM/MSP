# IAR project sensor.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MSP432P401R TexasInstruments MSP432P401R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __MSP432P401R__; ARM_MATH_CM4; ARM_MATH_MATRIX_CHECK; ARM_MATH_ROUNDING; __FPU_PRESENT
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\platform\hal; ..\..\platform\osel\; ..\..\platform\osel\uCOS-II\Config; ..\..\platform\osel\uCOS-II\Ports\ARM-Cortex-M\ARMv7-M\IAR; ..\..\platform\osel\uCOS-II\Source; ..\..\include\platform; ..\..\include\platform\hal; ..\..\include\platform\lib; ..\..\include\platform\osel; ..\..\include\sensor; ..\..\include\app; ..\..\include\stack
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: sensor.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: fxos8700cq.c sensor.c
  group include/platform
    ../../include/platform/: platform.h
  group include/platform/hal
    ../../include/platform/hal/: hal_mem.h hal_misc.h hal_rf.h hal_stimer.h hal_timer.h hal_uart.h
  group include/platform/lib
    ../../include/platform/lib/: check.h debug.h kbuf.h list.h memory.h queue.h
  group include/platform/osel
    ../../include/platform/osel/: osel_event.h osel_kernel.h osel_task.h
  group include/sensor
    ../../include/sensor/: fxos8700cq.h sensor.h
